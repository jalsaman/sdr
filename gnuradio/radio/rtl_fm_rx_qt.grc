options:
  parameters:
    author: Muthanna A. Alwahash
    category: Custom
    generate_options: qt_gui
    id: rtl_fm_rx_qt
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: FM_Frequency
  id: variable_qtgui_range
  parameters:
    label: FM Channel Frequency
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 94.4e6
  states: {}
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: FM_Frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2e6
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
